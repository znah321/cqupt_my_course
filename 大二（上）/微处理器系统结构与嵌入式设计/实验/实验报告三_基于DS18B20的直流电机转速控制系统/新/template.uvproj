# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template111 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\智能控制1
  group Source Group 1
    ./: main.c temp.c i2c.c XPT2046.c
